# Keil uVision project obstacle_avoidance.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: obstacle_avoidance
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..\..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_rvmdk.S obstacle_avoidance.c
    ../../../../../driverlib/rvmdk/: driverlib.lib
